# Keil uVision project SpaceInvaders.uvproj, settings and files
target SpaceInvaders (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: LM4F120H5QR Texas Instruments
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0-0x3FFFF) CLOCK(8000000) CPUTYPE("Cortex-M4") FPU2
  output: SpaceInvaders
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: rvmdk PART_LM4F120H5QR
  c include: ..;..\..\..
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Source
    ./: startup.s Nokia5110.c random.s SpaceInvaders.c TExaS.c Images.c Images.h ADC.c ADC.h DAC.h DAC.c Sound.c Sound.h Timer2.c Timer2.h Switch.h Switch.c LED.c LED.h Sprites.c Sprites.h
